options:
  parameters:
    author: Barry Duggan
    description: packet FSK xmt
    generate_options: qt_gui
    id: pkt_fsk_xmt
    output_language: python
    title: pkt_fsk_xmt
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: ' pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(1,240))'
    period: '1000'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '9'
    size: '4000'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_TAG
    type: complex
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_pack_k_bits_bb_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_throttle_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_throttle_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_mod_0, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.9.7.0
